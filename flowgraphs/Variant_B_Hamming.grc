options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: variant_b_hamming
    output_language: python
    run_command: '{python} -u {filename} '
    title: MPSK channel with Noise and Hamming Encoding
  states: {}

blocks:
- name: modulation
  id: variable_constellation
  parameters:
    const_points: modulation_config.get_constellation(modulation_name)
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: modulation_config.get_symbol_map(modulation_name)
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: modulation_config.calculate_noise("QPSK",9,4)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: modulation_config.calculate_noise("QPSK",9,7)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: 2**modulation.bits_per_symbol()
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_copy_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Hamming (7,4) Encoder',
                  in_sig=[np.int8],
                  out_sig=[np.int8],
              )
              self._buffer = []
              self._offset = 0

          def _compact(self):
              if self._offset >= 1024 and self._offset >= len(self._buffer) // 2:
                  self._buffer = self._buffer[self._offset:]
                  self._offset = 0

          def general_work(self, input_items, output_items):
              incoming = input_items[0]
              if len(incoming):
                  self._buffer.extend((incoming.astype(np.int8, copy=False) & 1).tolist())
              self.consume_each(len(incoming))

              out = output_items[0]
              available = len(self._buffer) - self._offset
              blocks = min(available // 4, len(out) // 7)
              if blocks <= 0:
                  self._compact()
                  return 0

              out_index = 0
              start = self._offset
              for block in range(blocks):
                  base = start + block * 4
                  d1 = self._buffer[base]
                  d2 = self._buffer[base + 1]
                  d3 = self._buffer[base + 2]
                  d4 = self._buffer[base + 3]
                  out[out_index] = d1 ^ d2 ^ d4
                  out[out_index + 1] = d1 ^ d3 ^ d4
                  out[out_index + 2] = d1
                  out[out_index + 3] = d2 ^ d3 ^ d4
                  out[out_index + 4] = d2
                  out[out_index + 5] = d3
                  out[out_index + 6] = d4
                  out_index += 7

              self._offset += blocks * 4
              self._compact()
              return out_index
    enabled: 'True'
    showports: 'False'
  states: {}
- name: blocks_copy_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name='Hamming (7,4) Decoder',
                  in_sig=[np.int8],
                  out_sig=[np.int8],
              )
              self._buffer = []
              self._offset = 0

          def _compact(self):
              if self._offset >= 1024 and self._offset >= len(self._buffer) // 2:
                  self._buffer = self._buffer[self._offset:]
                  self._offset = 0

          def general_work(self, input_items, output_items):
              incoming = input_items[0]
              if len(incoming):
                  self._buffer.extend((incoming.astype(np.int8, copy=False) & 1).tolist())
              self.consume_each(len(incoming))

              out = output_items[0]
              available = len(self._buffer) - self._offset
              blocks = min(available // 7, len(out) // 4)
              if blocks <= 0:
                  self._compact()
                  return 0

              out_index = 0
              start = self._offset
              for block in range(blocks):
                  base = start + block * 7
                  c0 = self._buffer[base]
                  c1 = self._buffer[base + 1]
                  c2 = self._buffer[base + 2]
                  c3 = self._buffer[base + 3]
                  c4 = self._buffer[base + 4]
                  c5 = self._buffer[base + 5]
                  c6 = self._buffer[base + 6]
                  s1 = c0 ^ c2 ^ c4 ^ c6
                  s2 = c1 ^ c2 ^ c5 ^ c6
                  s3 = c3 ^ c4 ^ c5 ^ c6
                  error_position = s1 + (s2 << 1) + (s3 << 2)
                  codeword = [c0, c1, c2, c3, c4, c5, c6]
                  if 1 <= error_position <= 7:
                      codeword[error_position - 1] ^= 1
                  out[out_index] = codeword[2]
                  out[out_index + 1] = codeword[4]
                  out[out_index + 2] = codeword[5]
                  out[out_index + 3] = codeword[6]
                  out_index += 4

              self._offset += blocks * 7
              self._compact()
              return out_index
    enabled: 'True'
    showports: 'False'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: modulation.bits_per_symbol()
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: modulation.bits_per_symbol()
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: modulation.bits_per_symbol()
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: modulation.bits_per_symbol()
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: modulation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: modulation
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: modulation
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: modulation
  states: {}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: modulation
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: measurement_control_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: BER MPSK
    num_tabs: '1'
  states: {}
- name: modulation_config
  id: epy_module
  parameters:
    source_code: "\r\nimport numpy as np\r\n\r\ndef get_constellation(modulation):\r\n    \"\"\"\r\n    Returns the constellation points for the specified modulation scheme.\r\n\r\n    Parameters:\r\n    modulation (str): The modulation scheme ('BPSK', 'QPSK').\r\n\r\n    Returns:\r\n    numpy.ndarray: Array of constellation points.\r\n    \"\"\"\r\n    modulation = modulation.upper()\r\n\r\n    constellations = {\r\n    'BPSK': lambda: np.array([-1, 1]),\r\n    'QPSK': lambda: np.array([1+1j, 1-1j, -1+1j, -1-1j])\r\n    }\r\n\r\n\r\n    if modulation in constellations:\r\n        return constellations[modulation]()\r\n    else:\r\n        raise ValueError(\"Unsupported modulation type. Use 'BPSK', 'QPSK'.\")\r\n\r\ndef get_symbol_map(modulation):\r\n    \"\"\"\r\n    Returns the symbol map for the specified modulation scheme.\r\n\r\n    Parameters:\r\n    modulation (str): The modulation scheme ('BPSK', 'QPSK').\r\n\r\n    Returns:\r\n    list: A list of symbol indices for the specified modulation scheme.\r\n    \"\"\"\r\n    modulation = modulation.upper()\r\n    symbol_counts = {\r\n        'BPSK': 2,\r\n        'QPSK': 4,\r\n    }\r\n\r\n    if modulation in symbol_counts:\r\n        return [i for i in range(symbol_counts[modulation])]\r\n    else:\r\n        raise ValueError(\"Unsupported modulation type. Use 'BPSK', 'QPSK'.\")\r\n\r\n\r\nimport math\r\n\r\ndef calculate_noise(modulation: str, ebno: float, k: int): \r\n    if modulation == 'BPSK':\r\n        snr_linear = 10 ** (ebno / 10) + 10*math.log(k/7,10)\r\n        noise_variance = 1 / snr_linear \r\n        noise = math.sqrt(noise_variance)\r\n        return noise\r\n\r\n    elif modulation == 'QPSK':\r\n        snr_db = ebno + 10*math.log(2,10) + 10*math.log(k/7,10)\r\n        snr_linear = 10 ** (snr_db / 10)\r\n        noise_variance = 1 / snr_linear \r\n        noise = math.sqrt(noise_variance)\r\n        return noise"
  states: {}
- name: modulation_name
  id: parameter
  parameters:
    label: Modulation Name
    type: str
    value: QPSK
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    color1: '"red"'
    color2: '"blue"'
    grid: 'True'
    gui_hint: 3,0,2,1
    label1: Noise-Affected MPSK
    label2: Noise-Free MPSK
    name: 'Comparison of MPSK Signal Constellations: Noise-Free vs. Noise-Affected'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    alpha1: '0.8'
    alpha2: '1'
    bins: '10'
    color1: '"red"'
    color2: '"blue"'
    grid: 'True'
    gui_hint: 3,1,2,1
    label1: Uncoded MPSK
    label2: Hamming Code MPSK
    marker1: '0'
    marker2: '3'
    name: 'MPSK Error Rate Histogram: Hamming Code vs. No ECC'
    nconnections: '2'
    size: '5000'
    type: float
    xmax: '1.2'
    xmin: '0.95'
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'measurement_control_0@0: 0,1,1,1'
    label1: BER
    min: '0'
    name: '"BER Output with Hamming Encoding"'
    type: float
    unit1: = X
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 'measurement_control_0@0: 0,0,1,1'
    label1: BER
    min: '0'
    name: '"BER Output without Hamming Encoding"'
    type: float
    unit1: = X
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    label2: ''
    label3: ''
    name: ''
    nconnections: '3'
    size: '64'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from PyQt5 import QtWidgets

      # Apply a custom font size to all widgets
      app = QtWidgets.QApplication.instance()
      if app is not None:
          app.setStyleSheet("QWidget { font-size: 22px; }")  # Adjust size
    section: main_after_init
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: hamming_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: hamming_signal_output
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: signal_output
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: hamming_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: r2
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: signal_output
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: hamming_signal_output
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: hamming_signal_output
  states: {}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: signal_output
  states: {}
- name: virtual_source_1_0_1
  id: virtual_source
  parameters:
    stream_id: r3
  states: {state: disabled}
- name: virtual_source_1_0_2
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_source_1_0_2_0
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: t1
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {}
- name: virtual_source_2_1_0
  id: virtual_source
  parameters:
    stream_id: original_signal
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_2, '0']
- [blocks_abs_xx_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_histogram_sink_x_0, '1']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_char_to_float_0_0_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_char_to_float_0_0_1, '0', blocks_sub_xx_0, '0']
- [blocks_char_to_float_0_0_1_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_char_to_float_0_0_1_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_copy_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_copy_0_0, '0', blocks_repack_bits_bb_0_1, '0']
- [blocks_repack_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_copy_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_copy_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', virtual_sink_1, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_sub_xx_0_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_1_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', fec_ber_bf_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', fec_ber_bf_0, '1']
- [blocks_unpacked_to_packed_xx_0_1, '0', fec_ber_bf_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_1_0, '0', fec_ber_bf_0_0, '1']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_add_xx_0, '1']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_constellation_encoder_bc_0_0, '0', blocks_add_xx_0_0, '1']
- [fec_ber_bf_0, '0', qtgui_number_sink_0_0_0, '0']
- [fec_ber_bf_0_0, '0', qtgui_number_sink_0_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_1_0, '0', blocks_char_to_float_0_0_1, '0']
- [virtual_source_1_0_0, '0', blocks_char_to_float_0_0_1_0, '0']
- [virtual_source_1_0_0_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [virtual_source_1_0_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [virtual_source_1_0_1, '0', blocks_char_to_float_0_0_1_1, '0']
- [virtual_source_1_0_2, '0', blocks_unpacked_to_packed_xx_0_1_0, '0']
- [virtual_source_1_0_2_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [virtual_source_2, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_2_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [virtual_source_2_1, '0', blocks_char_to_float_0_0_0_0, '0']
- [virtual_source_2_1_0, '0', blocks_char_to_float_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
